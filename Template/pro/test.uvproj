# Keil uVision project test.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\h;..\main
  group main
    ../main/: main.c
  group jz
    ../c/: jz.c
  group delay
    ../c/: delay.c
  group DigDisplay
    ../c/: DigDisplay.c
  group i2c
    ../c/: i2c.c
